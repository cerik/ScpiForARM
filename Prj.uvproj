# Keil uVision project Prj.uvproj, settings and files
target 1 (ARM-ADS)
  device: STM32F107RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: ScpiPrj +hex
  c define: USE_STDPERIPH_DRIVER,LWIP,USB,SCPI, STM32F10X_CL
  c include: .\Src\Inc;.\Utilities\Usb\Inc;.\Utilities\Scpi\Inc;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\STM32_ETH_Driver\inc;.\Utilities\lwip-1.3.1\src\include;.\Utilities\lwip-1.3.1\src\include\ipv4;.\Utilities\lwip-1.3.1\port
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group UserSrc
    ./Src/Src/: bsp.c crc.c flash.c getstr.c main.c scpi-def.c netconf.c
  group BspSrc
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_crc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
    ./Libraries/STM32_ETH_Driver/src/: stm32_eth.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
  group UsbSrc
    ./Utilities/Usb/Src/: hw_config.c usb_core.c usb_desc.c usb_endp.c usb_init.c usb_int.c usb_istr.c usb_mem.c usb_prop.c usb_pwr.c usb_regs.c usb_tmc.c
  group ScpiSrc
    ./Utilities/Scpi/Src/: error.c expression.c fifo.c ieee488.c lexer.c minimal.c parser.c snprintf.c units.c utils.c
  group LwIP
    ./Utilities/lwip-1.3.1/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ./Utilities/lwip-1.3.1/src/core/ipv4/: autoip.c icmp.c inet.c ip.c ip_frag.c ip_addr.c inet_chksum.c igmp.c
    ./Utilities/lwip-1.3.1/src/api/: tcpip.c sockets.c err.c api_msg.c api_lib.c netifapi.c netdb.c netbuf.c
    ./Utilities/lwip-1.3.1/port/: ethernetif.c
    ./Utilities/lwip-1.3.1/src/netif/: etharp.c
